#pragma once
#include <cstdint>
#include <cstring>
#include <cstddef>

// ---------------------------------------------------------------------
// AES-128 (ECB, un seul bloc a la fois) — implementation autonome,
// sans dependance a mbedtls. Adaptee de l'algorithme public FIPS-197
// (structure "tiny-AES" largement utilisee dans l'embarque).
// ---------------------------------------------------------------------
namespace aes128 {

static const uint8_t sbox[256] = {
  0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
  0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
  0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
  0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
  0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
  0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
  0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
  0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
  0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
  0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
  0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
  0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
  0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
  0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
  0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
  0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static const uint8_t rsbox[256] = {
  0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
  0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
  0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
  0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
  0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
  0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
  0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
  0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
  0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
  0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
  0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
  0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
  0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
  0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
  0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
  0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

static const uint8_t Rcon[11] = {
  0x8d,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36
};

struct Ctx {
  uint8_t round_key[176];  // 11 * 16 pour AES-128
};

inline void key_expansion(Ctx *ctx, const uint8_t *key) {
  uint8_t *rk = ctx->round_key;
  memcpy(rk, key, 16);
  uint8_t tempa[4];
  for (unsigned i = 4; i < 44; i++) {
    memcpy(tempa, rk + 4 * (i - 1), 4);
    if (i % 4 == 0) {
      // RotWord
      uint8_t t = tempa[0];
      tempa[0] = tempa[1]; tempa[1] = tempa[2]; tempa[2] = tempa[3]; tempa[3] = t;
      // SubWord
      tempa[0] = sbox[tempa[0]]; tempa[1] = sbox[tempa[1]];
      tempa[2] = sbox[tempa[2]]; tempa[3] = sbox[tempa[3]];
      tempa[0] ^= Rcon[i / 4];
    }
    rk[4*i+0] = rk[4*(i-4)+0] ^ tempa[0];
    rk[4*i+1] = rk[4*(i-4)+1] ^ tempa[1];
    rk[4*i+2] = rk[4*(i-4)+2] ^ tempa[2];
    rk[4*i+3] = rk[4*(i-4)+3] ^ tempa[3];
  }
}

inline void add_round_key(uint8_t round, uint8_t state[16], const uint8_t *rk) {
  for (int i = 0; i < 16; i++) state[i] ^= rk[round * 16 + i];
}
inline void sub_bytes(uint8_t state[16]) { for (int i = 0; i < 16; i++) state[i] = sbox[state[i]]; }
inline void inv_sub_bytes(uint8_t state[16]) { for (int i = 0; i < 16; i++) state[i] = rsbox[state[i]]; }

// state[16] est stocke colonne-major : state[col*4+row]
inline void shift_rows(uint8_t s[16]) {
  uint8_t t;
  // ligne 1 : rotation gauche de 1
  t = s[1]; s[1] = s[5]; s[5] = s[9]; s[9] = s[13]; s[13] = t;
  // ligne 2 : rotation gauche de 2
  t = s[2]; s[2] = s[10]; s[10] = t; t = s[6]; s[6] = s[14]; s[14] = t;
  // ligne 3 : rotation gauche de 3 (= droite de 1)
  t = s[15]; s[15] = s[11]; s[11] = s[7]; s[7] = s[3]; s[3] = t;
}
inline void inv_shift_rows(uint8_t s[16]) {
  uint8_t t;
  t = s[13]; s[13] = s[9]; s[9] = s[5]; s[5] = s[1]; s[1] = t;
  t = s[2]; s[2] = s[10]; s[10] = t; t = s[6]; s[6] = s[14]; s[14] = t;
  t = s[3]; s[3] = s[7]; s[7] = s[11]; s[11] = s[15]; s[15] = t;
}

inline uint8_t xtime(uint8_t x) { return (uint8_t)((x << 1) ^ ((x >> 7) * 0x1b)); }
inline uint8_t gmul(uint8_t a, uint8_t b) {
  uint8_t p = 0;
  for (int i = 0; i < 8; i++) {
    if (b & 1) p ^= a;
    uint8_t hi = a & 0x80;
    a <<= 1;
    if (hi) a ^= 0x1b;
    b >>= 1;
  }
  return p;
}

inline void mix_columns(uint8_t s[16]) {
  for (int c = 0; c < 4; c++) {
    uint8_t *col = s + 4 * c;
    uint8_t a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
    col[0] = (uint8_t)(xtime(a0) ^ (xtime(a1) ^ a1) ^ a2 ^ a3);
    col[1] = (uint8_t)(a0 ^ xtime(a1) ^ (xtime(a2) ^ a2) ^ a3);
    col[2] = (uint8_t)(a0 ^ a1 ^ xtime(a2) ^ (xtime(a3) ^ a3));
    col[3] = (uint8_t)((xtime(a0) ^ a0) ^ a1 ^ a2 ^ xtime(a3));
  }
}
inline void inv_mix_columns(uint8_t s[16]) {
  for (int c = 0; c < 4; c++) {
    uint8_t *col = s + 4 * c;
    uint8_t a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
    col[0] = (uint8_t)(gmul(a0,0x0e) ^ gmul(a1,0x0b) ^ gmul(a2,0x0d) ^ gmul(a3,0x09));
    col[1] = (uint8_t)(gmul(a0,0x09) ^ gmul(a1,0x0e) ^ gmul(a2,0x0b) ^ gmul(a3,0x0d));
    col[2] = (uint8_t)(gmul(a0,0x0d) ^ gmul(a1,0x09) ^ gmul(a2,0x0e) ^ gmul(a3,0x0b));
    col[3] = (uint8_t)(gmul(a0,0x0b) ^ gmul(a1,0x0d) ^ gmul(a2,0x09) ^ gmul(a3,0x0e));
  }
}

inline void set_key(Ctx *ctx, const uint8_t key[16]) { key_expansion(ctx, key); }

inline void encrypt_block(const Ctx *ctx, const uint8_t in[16], uint8_t out[16]) {
  uint8_t s[16];
  memcpy(s, in, 16);
  add_round_key(0, s, ctx->round_key);
  for (int round = 1; round < 10; round++) {
    sub_bytes(s);
    shift_rows(s);
    mix_columns(s);
    add_round_key(round, s, ctx->round_key);
  }
  sub_bytes(s);
  shift_rows(s);
  add_round_key(10, s, ctx->round_key);
  memcpy(out, s, 16);
}

inline void decrypt_block(const Ctx *ctx, const uint8_t in[16], uint8_t out[16]) {
  uint8_t s[16];
  memcpy(s, in, 16);
  add_round_key(10, s, ctx->round_key);
  for (int round = 9; round >= 1; round--) {
    inv_shift_rows(s);
    inv_sub_bytes(s);
    add_round_key(round, s, ctx->round_key);
    inv_mix_columns(s);
  }
  inv_shift_rows(s);
  inv_sub_bytes(s);
  add_round_key(0, s, ctx->round_key);
  memcpy(out, s, 16);
}

}  // namespace aes128

// ---------------------------------------------------------------------
// SHA-256 — implementation autonome (algorithme public FIPS-180-4),
// utilisee pour Utils::sha256() et pour HMAC-SHA256 (encrypt-then-MAC).
// ---------------------------------------------------------------------
namespace sha256_impl {

struct Ctx {
  uint32_t state[8];
  uint64_t bitlen;
  uint8_t buffer[64];
  size_t buffer_len;
};

static const uint32_t K[64] = {
  0x428a2f98,0x71374491,0xb5c0fbcf,0xe9b5dba5,0x3956c25b,0x59f111f1,0x923f82a4,0xab1c5ed5,
  0xd807aa98,0x12835b01,0x243185be,0x550c7dc3,0x72be5d74,0x80deb1fe,0x9bdc06a7,0xc19bf174,
  0xe49b69c1,0xefbe4786,0x0fc19dc6,0x240ca1cc,0x2de92c6f,0x4a7484aa,0x5cb0a9dc,0x76f988da,
  0x983e5152,0xa831c66d,0xb00327c8,0xbf597fc7,0xc6e00bf3,0xd5a79147,0x06ca6351,0x14292967,
  0x27b70a85,0x2e1b2138,0x4d2c6dfc,0x53380d13,0x650a7354,0x766a0abb,0x81c2c92e,0x92722c85,
  0xa2bfe8a1,0xa81a664b,0xc24b8b70,0xc76c51a3,0xd192e819,0xd6990624,0xf40e3585,0x106aa070,
  0x19a4c116,0x1e376c08,0x2748774c,0x34b0bcb5,0x391c0cb3,0x4ed8aa4a,0x5b9cca4f,0x682e6ff3,
  0x748f82ee,0x78a5636f,0x84c87814,0x8cc70208,0x90befffa,0xa4506ceb,0xbef9a3f7,0xc67178f2
};

inline uint32_t rotr(uint32_t x, uint32_t n) { return (x >> n) | (x << (32 - n)); }

inline void transform(Ctx *ctx, const uint8_t data[64]) {
  uint32_t m[64];
  for (int i = 0; i < 16; i++)
    m[i] = (data[i*4] << 24) | (data[i*4+1] << 16) | (data[i*4+2] << 8) | data[i*4+3];
  for (int i = 16; i < 64; i++) {
    uint32_t s0 = rotr(m[i-15], 7) ^ rotr(m[i-15], 18) ^ (m[i-15] >> 3);
    uint32_t s1 = rotr(m[i-2], 17) ^ rotr(m[i-2], 19) ^ (m[i-2] >> 10);
    m[i] = m[i-16] + s0 + m[i-7] + s1;
  }
  uint32_t a=ctx->state[0],b=ctx->state[1],c=ctx->state[2],d=ctx->state[3];
  uint32_t e=ctx->state[4],f=ctx->state[5],g=ctx->state[6],h=ctx->state[7];
  for (int i = 0; i < 64; i++) {
    uint32_t S1 = rotr(e,6) ^ rotr(e,11) ^ rotr(e,25);
    uint32_t ch = (e & f) ^ ((~e) & g);
    uint32_t temp1 = h + S1 + ch + K[i] + m[i];
    uint32_t S0 = rotr(a,2) ^ rotr(a,13) ^ rotr(a,22);
    uint32_t maj = (a & b) ^ (a & c) ^ (b & c);
    uint32_t temp2 = S0 + maj;
    h=g; g=f; f=e; e=d+temp1; d=c; c=b; b=a; a=temp1+temp2;
  }
  ctx->state[0]+=a; ctx->state[1]+=b; ctx->state[2]+=c; ctx->state[3]+=d;
  ctx->state[4]+=e; ctx->state[5]+=f; ctx->state[6]+=g; ctx->state[7]+=h;
}

inline void init(Ctx *ctx) {
  ctx->state[0]=0x6a09e667; ctx->state[1]=0xbb67ae85; ctx->state[2]=0x3c6ef372; ctx->state[3]=0xa54ff53a;
  ctx->state[4]=0x510e527f; ctx->state[5]=0x9b05688c; ctx->state[6]=0x1f83d9ab; ctx->state[7]=0x5be0cd19;
  ctx->bitlen = 0; ctx->buffer_len = 0;
}

inline void update(Ctx *ctx, const uint8_t *data, size_t len) {
  for (size_t i = 0; i < len; i++) {
    ctx->buffer[ctx->buffer_len++] = data[i];
    if (ctx->buffer_len == 64) {
      transform(ctx, ctx->buffer);
      ctx->bitlen += 512;
      ctx->buffer_len = 0;
    }
  }
}

inline void final(Ctx *ctx, uint8_t out[32]) {
  size_t i = ctx->buffer_len;
  ctx->bitlen += (uint64_t)ctx->buffer_len * 8;
  ctx->buffer[i++] = 0x80;
  if (i > 56) {
    while (i < 64) ctx->buffer[i++] = 0;
    transform(ctx, ctx->buffer);
    i = 0;
  }
  while (i < 56) ctx->buffer[i++] = 0;
  for (int j = 7; j >= 0; j--) ctx->buffer[i++] = (uint8_t)(ctx->bitlen >> (j * 8));
  transform(ctx, ctx->buffer);
  for (int j = 0; j < 4; j++) {
    for (int k = 0; k < 8; k++)
      out[k*4+j] = (uint8_t)(ctx->state[k] >> (24 - j*8));
  }
}

inline void hash(const uint8_t *data, size_t len, uint8_t out[32]) {
  Ctx ctx; init(&ctx); update(&ctx, data, len); final(&ctx, out);
}

inline void hmac(const uint8_t *key, size_t key_len, const uint8_t *data, size_t data_len, uint8_t out[32]) {
  uint8_t k0[64];
  memset(k0, 0, sizeof(k0));
  if (key_len > 64) { hash(key, key_len, k0); } else { memcpy(k0, key, key_len); }

  uint8_t ipad[64], opad[64];
  for (int i = 0; i < 64; i++) { ipad[i] = k0[i] ^ 0x36; opad[i] = k0[i] ^ 0x5c; }

  Ctx ctx;
  init(&ctx);
  update(&ctx, ipad, 64);
  update(&ctx, data, data_len);
  uint8_t inner[32];
  final(&ctx, inner);

  init(&ctx);
  update(&ctx, opad, 64);
  update(&ctx, inner, 32);
  final(&ctx, out);
}

}  // namespace sha256_impl
